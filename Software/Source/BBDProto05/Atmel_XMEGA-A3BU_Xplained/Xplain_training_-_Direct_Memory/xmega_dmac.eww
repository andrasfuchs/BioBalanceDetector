<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\task 1 - Memory Copy\memorycopy.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\task 2 - Recorder\recorder.ewp</path>
  </project>
  <batchBuild/>
</workspace>


